# Keil uVision project pwr_mng.uvprojx, settings and files
target pwr_mng (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pwr_mng
  c flags: Optim=2 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\Library\Libraries\CMSIS\CM3\CoreSupport;.\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\;.\inc;.\config;.\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;.\src_fatfs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDR32F9Qx_FWLib
    ./Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_wwdg.c MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_eeprom.c MDR32F9Qx_ebc.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c
  group MDR32F9Qx_USBLib
    ./Library/Libraries/MDR32F9Qx_StdPeriph_Driver/src/USB_Library/: MDR32F9Qx_usb_device.c MDR32F9Qx_usb_CDC.c
  group MDR32F9Qx_FatFsLib
    ./src_fatfs/: rtc.c ff.c mmc.c
  group target
    ./Library/Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group user
    ./src/: Demo_Init_MDR32F9Q1.c Demo_Init_MDR32F9Qx.c Main.c MDR32F9Qx_it.c Menu.c Menu_gl.c Menu_leds.c Menu_lowpower.c Menu_text.c Menu_time.c Menu_tsensor.c Menu_uart.c Menu_uSDFlash.c Menu_VCOM.c
  group inc
    ./inc/: Demo_Init.h LowPower.h MDR32F9Qx_it.h MDR32F9Qx_usb_handlers.h Menu.h Menu_items.h Menu_uSDFlash.h time.h
  group joystick
    ./inc/: joystick.h
    ./src/: joystick.c
  group lcd
    ./src/: text.c lcd_MDR32F9Q1.c lcd_MDR32F9Qx.c gl.c
    ./inc/: text.h lcd_MDR32F9Q1.h lcd_MDR32F9Qx.h lcd.h gl.h
  group fonts
    ./inc/: font_defs.h
    ./fonts/: Font_6x8.c Font_7x10_bold.c Font_7x10_thin.c Font_12x16.c
  group leds
    ./src/: leds.c
    ./inc/: leds.h
  group adc
    ./src/: adc.c
    ./inc/: ADC.h
  group common
    ./src/: systick.c
    ./inc/: systick.h types.h
  group config
    ./config/: MDR32F9Qx_board.h MDR32F9Qx_config.h
